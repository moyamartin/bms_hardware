# Repository moyamartin/bms_hardware

File README.md:

# Battery Management System (BMS) - Hardware

This is the hardware design section of the [BMS project](https://github.com/moyamartin/bms_unr). It was designed with [KiCAD](https://kicad.org/).

Here you will find the design, gerber, [BOM](https://moyamartin.github.io/bms_hardware/) and [render](./render/) files of the PCB.

## Features

As the main goal of this project, this board is designed to support a li-ion
battery pack with a 6 series - 3 parallel architecture based on 18650PF cells
following the next goals:

* Protection
* Balancing
* Charging/Discharging
* Temperature measurement
* Battery SoC (State of Charge) estimation

## Design components/considerations

To meet the project's requirements we have chosen the following components with
their respective role:

* [BQ76PL536A](https://www.ti.com/product/BQ76PL536A): This is a 3 to 6 series
  lithium-ion battery monitor and secondary protection. It is used as a frontend
  analog device to measure each series cell voltage and it has dedicated outputs
  to balance passively through resistors the desired cell.

* [INA226](https://www.ti.com/lit/ds/symlink/ina226.pdf): Bi-Directional current
  and power monitor with I2C compatible interface, we are using this to measure
  the discharge current, fusioning this data with the voltage measurement of
  each cell we can infere the SoC of each cell.

* [BQ24618](https://www.ti.com/lit/ds/symlink/bq24618.pdf): 6 cells Li-Ion
  battery charger, designed to charge the battery pack at a 4A rate with led
  status indication.

* [STM32F407VGTx](https://www.st.com/en/microcontrollers-microprocessors/stm32f407vg.html): ARM Cortex-M microcontroller with DSP instructions and FPU unit, used to estimate the SoC and control all the peripherals and sensors through their respectives communication protocols applying all the mentioned features earlier. It is enabled to interact with other external devices (such as an on-board computer) through CAN and RS232.

* [SN65HVD233](https://www.ti.com/lit/ds/symlink/sn65hvd233.pdf): 3.3V CAN Bus
  transceiver to operate with the latter MCU compatible with ISO 11898 standard.
  This device is isolated from the rest of the components through the [ADuM1201AR](https://www.analog.com/media/en/technical-documentation/data-sheets/ADuM1200_1201.pdf).

* [IRF9310PbF](https://www.infineon.com/dgdl/irf9310pbf.pdf?fileId=5546d462533600a4015356110a7d1d95): Charge and Discarge switch for battery applications, this device is in charge of connection and disconnecting the load from the battery, basically, it's the main endpoint of proetection for the battery pack

## KiCad design bms_hardware.kicad_pcb

Parts:
+(BATT)1: MountingHole_Pad; MountingHole_3mm_Pad_TopBottom
+(LOAD)1: MountingHole_Pad; MountingHole_3mm_Pad_TopBottom
-(BATT)1: MountingHole_Pad; MountingHole_3mm_Pad_TopBottom
-(LOAD)1: MountingHole_Pad; MountingHole_3mm_Pad_TopBottom
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via

Connections:
/LOAD_OUTPUT+: +(LOAD)1.1; also elsewhere on the board
GND: -(BATT)1.1, -(LOAD)1.1; also elsewhere on the board

Parts:
C1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R1: 2.5mOhm 1W 1%; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R2, R3, R4: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U9: INA226; VSSOP-10_3x3mm_P0.5mm

Connections:
+BATT: R1.1, U9.8 (Vbus), U9.10 (Vin+); also elsewhere on the board
/bat_switch/D: R1.2, U9.9 (Vin-); also elsewhere on the board
/current_sensor_ina226/ALERT_INA226: R4.2, U9.3 (~Alert~)
/current_sensor_ina226/SCL: R3.2, U9.5 (SCL); also elsewhere on the board
/current_sensor_ina226/SDA: R2.2, U9.4 (SDA); also elsewhere on the board
GND: C1.2, U9.1 (A1), U9.2 (A0), U9.7 (GND); also elsewhere on the board
VBAT: C1.1, R2.1, R3.1, R4.1, U9.6 (VS); also elsewhere on the board

Notes on the sheet:
NOTAS
- La corriente maxima esperada a consumir es de alrededor de 20A. Por lo tanto, la resistencia calculada es de 2.5mOhm 1W 1% - La dirección I2C predefinida por los pines A0 y A1 es la 0x80, ya que ambos pines están conectados a masa. - La entrada de corriente no se filtra ya que no se pretenden cor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

Parts:
C2: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 10uF, low-ESR ceramic capacitor; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C7: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C8, C9: 2.2uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J2: Conn_01x07_Female; JST_XH_S7B-XH-A_1x07_P2.50mm_Horizontal
R8, R9, R10, R11: 1.8K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TH1, TH2: 10K 1%; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
U2: BQ76PL536APAPR; HTQFP-64-1EP_10x10mm_P0.5mm_EP8x8mm_Mask4.4x4.4mm_ThermalVi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

Connections:
+24V: C2.1, J2.1, U2.52, U2.53, U2.54, U2.55, U2.56, U2.57, U2.58, U2.59, U2.63, U2.64; also elsewhere on the board
/equalizer_bq76/ALERT_BQ76: U2.38; also elsewhere on the board
/equalizer_bq76/CS: U2.43; also elsewhere on the board
/equalizer_bq76/balancing_module/CB1: U2.12; also elsewhere on the board
/equalizer_bq76/balancing_module/CB2: U2.10; also elsewhere on the board
/equalizer_bq76/balancing_module/CB3: U2.8; also elsewhere on the board
/equalizer_bq76/balancing_module/CB4: U2.6; also elsewhere on the board
/equalizer_bq76/balancing_module/CB5: U2.4; also elsewhere on the board
/equalizer_bq76/balancing_module/CB6: U2.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_1+: J2.6; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_2+: J2.5; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_3+: J2.4; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_4+: J2.3; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_5+: J2.2; also elsewhere on the board
/equalizer_bq76/balancing_module/VC1: U2.11; also elsewhere on the board
/equalizer_bq76/balancing_module/VC2: U2.9; also elsewhere on the board
/equalizer_bq76/balancing_module/VC3: U2.7; also elsewhere on the board
/equalizer_bq76/balancing_module/VC4: U2.5; also elsewhere on the board
/equalizer_bq76/balancing_module/VC5: U2.3; also elsewhere on the board
/equalizer_bq76/balancing_module/VC6: U2.1; also elsewhere on the board
/mcu_stm32f407/BQ76_CONV: U2.36; also elsewhere on the board
/mcu_stm32f407/BQ76_DRDY: U2.37; also elsewhere on the board
/mcu_stm32f407/BQ76_FAULT: U2.39; also elsewhere on the board
/mcu_stm32f407/MISO: U2.41; also elsewhere on the board
/mcu_stm32f407/MOSI: U2.42; also elsewhere on the board
/mcu_stm32f407/SCK: U2.40; also elsewhere on the board
GND: C2.2, C3.2, C5.2, C6.2, C8.2, C9.2, J2.7, U2.13, U2.14, U2.15, U2.21, U2.22, U2.23, U2.24, U2.25, U2.26, U2.27, U2.28, U2.29, U2.33, U2.34, U2.35, U2.44, U2.49, U2.50, U2.65; also elsewhere on the board
LDOA: C5.1, U2.17
LDOD1: C6.1, U2.18
LDOD2: C8.1, U2.46
unnamed: C3.1, U2.16
unnamed: R8.1, TH1.2
unnamed: R10.1, TH2.2
unnamed: U2.47, U2.48
REG50: C4.1, C7.1, C9.1, TH1.1, TH2.1, U2.32
TS1+: C4.2, R8.2, R9.1, U2.20
TS1-: R9.2, U2.19
TS2+: C7.2, R10.2, R11.1, U2.61
TS2-: R11.2, U2.60

Notes on the sheet:
LDO Cap. Filters
NOTES
- General-purpose (differential) analog input not used. (GPAI+, GPAI- to GND) - Host interface enable -> HSEL = GND - GPIO not used -> connected to GND - TEST pin is a factory test pin, for user purposes it needs to be connected to GND - LDOA, LDOD1, LDOD2 y REG50 only need a 2.2uF cap for stability
Temp. Sensor passive circuit

Parts:
C22, C23, C30: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C24: 2.7nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25, C26, C27, C31, C32, C33: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 0.056uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C29, C34, C35: 10uF; C_Elec_6.3x7.7
D13: N4007; D_A-405_P7.62mm_Horizontal
D14: VCC; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D15: PG; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D16: STAT2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D17: STAT1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D18: RB541SM-40FHT2R; D_SOD-523
J3: Vcc In; Molex_KK-396_A-41791-0002_1x02_P3.96mm_Vertical
J4: CH_TS; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1: 6.8uH; L_BOURNS_SRP6030
NT1: GND-TIE; NetTie-2_SMD_Pad2.0mm
Q7, Q8: DMP4051LK3; TO-252-2
Q9, Q10: FDD86580-F085; TO-252-2
R36: 10k 1/8W 5%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R37: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R38: 6R2 1/4W 1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R39: 0R010⁯ 1W 0.5%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R40, R41: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R42: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R43: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R44: 5K6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R45, R46, R47: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R48, R49, R54: 10K*; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R50: 37K*; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R51: 8K2*; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R52: 0R020 1W 0.5%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R53: 6K8*; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R55: 1K 1/8W 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R56: 560K 1/10W 0.5%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R57: 51K 1/8W 0.5%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Reset; SW_TH_Tactile_Omron_B3F-10xx
SW2: Select CE; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W7.62mm_P2.54mm_LowProfile
TP1: GND_BAT; KEYSTONE_5016
TP2: GNDA; KEYSTONE_5016
TP3: VREF; KEYSTONE_5016
TP4: VBUS; KEYSTONE_5016
TP5: VCC; KEYSTONE_5016
TP6: CH_BAT; KEYSTONE_5016
U3: BQ24618RGET; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias

Connections:
+BATT: C32.1, C34.1, C35.1, R52.1, R55.1, TP6.1, U3.13 (SRN); also elsewhere on the board
/bat_charger/ACDRV: R43.2, U3.3 (*ACDRV)
/bat_charger/ACN: C25.2, C29.1, Q9.2 (D), R39.1, U3.1 (ACN)
/bat_charger/ACP: C25.1, C26.1, Q8.2 (D), R39.2, U3.2 (ACP)
/bat_charger/ACSET: R53.2, R54.1, U3.16 (ACSET)
/bat_charger/BATDRV: U3.23 (*BATDRV)
/bat_charger/BTST: C31.1, D18.1 (K), U3.22 (BTST)
/bat_charger/CE: SW2.3, SW2.4, U3.4 (CE)
/bat_charger/HIDRV: Q9.1 (G), U3.21 (HIDRV)
/bat_charger/ISET1: R48.2, R49.1, U3.11 (ISET1)
/bat_charger/ISET2: R50.2, R51.1, U3.15 (ISET2)
/bat_charger/LODRV: Q10.1 (G), U3.19 (LODRV)
/bat_charger/PH: C31.2, L1.2, Q9.3 (S), Q10.2 (D), U3.20 (PH)
/bat_charger/REGN: C30.1, D18.2 (A), U3.18 (REGN)
/bat_charger/SRP: C32.2, C33.2, L1.1, R52.2, U3.14 (SRP)
/bat_charger/TTC: C28.1, U3.7 (TTC)
/bat_charger/VBUS: C27.1, Q7.3 (S), Q8.3 (S), R37.2, R42.1, TP4.1
/bat_charger/VCC: C23.1, R37.1, R44.1, TP5.1, U3.24 (VCC)
/bat_charger/VFB: R56.2, R57.1, U3.12 (VFB)
/bat_charger/VREF: C22.1, D15.2 (A), D16.2 (A), D17.2 (A), R36.1, R40.1, R48.1, R50.1, R53.1, TP3.1, U3.10 (VREF)
/mcu_stm32f407/BQ24_CE: SW2.2; also elsewhere on the board
/mcu_stm32f407/BQ24_PG: R45.1, U3.8 (*PG); also elsewhere on the board
/mcu_stm32f407/BQ24_STAT1: R47.1, U3.5 (STAT1); also elsewhere on the board
/mcu_stm32f407/BQ24_STAT2: R46.1, U3.9 (STAT2); also elsewhere on the board
GND: C29.2, C30.2, C34.2, C35.2, NT1.1, Q10.3 (S), TP1.1, U3.25 (EPAD); also elsewhere on the board
GND1: C22.2, C23.2, C24.2, C26.2, C28.2, C33.1, D13.2 (A), D14.1 (K), J3.2, J4.1, NT1.2, R41.2, R49.2, R51.2, R54.2, R57.2, SW1.2, SW1.4, TP2.1, U3.17 (GND)
unnamed: C24.1, R38.1
unnamed: C27.2, Q7.1 (G), Q8.1 (G), R42.2, R43.1
unnamed: D13.1 (K), J3.1, Q7.2 (D), R38.2
unnamed: D14.2 (A), R44.2
unnamed: D15.1 (K), R45.2
unnamed: D16.1 (K), R46.2
unnamed: D17.1 (K), R47.2
unnamed: J4.2, R40.2, R41.1, U3.6 (TS)
unnamed: R36.2, SW1.1, SW1.3, SW2.1
unnamed: R55.2, R56.1

Notes on the sheet:
Status LEDs & Signals
Reset & CE Source Selector
* 1 ON , 2 OFF: Stand Alone * 1 OFF , 2 ON : u Controlled
* 1/8W 0.5%
I & V Charging Set Points
* I (pre-charge) = V2set/(100*Rse) * I (fast charge) = V1set/(20*Rse) * Icset = max I imput = 5A
* Charge: CC-CV 0.5C (max) 4.20V, 100mA cut-off at 25°C
+VBATT = 2.1*[1+(R20+R21)/R22]
* Fast-charge safety timer range: Tcharge = 5hs / Cttc(C44) = 0.056uF * * TS is disables with Vref/2. If CH_TS is conected calc TS divider
* Vref max load 35mA!! (Actual = 16,5mA)
Input
Output

Parts:
C36: 3.3nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C37: 330nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C38, C42: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C39: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C40: 2.2nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C41: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D19: B340; D_SMC
L2: 6.8uH; L_BOURNS_SRP6030
R58: 330K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R59: 27K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R60: 9K1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R61: 1K8; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R62: 5K1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U4: TPS54331D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+24V: C37.1, C38.1, R58.1, U4.2; also elsewhere on the board
EN: R58.2, R59.1, U4.3
GND: C36.2, C37.2, C38.2, C41.2, C42.2, D19.1 (K), R59.2, R61.2, R62.2, U4.7; also elsewhere on the board
unnamed: C36.1, U4.4
unnamed: C39.1, U4.1
unnamed: C40.1, C41.1, U4.6
unnamed: C40.2, R62.1
PH: C39.2, D19.2 (A), L2.2, U4.8
VBAT: C42.1, L2.1, R60.1; also elsewhere on the board
VSENSE: R60.2, R61.1, U4.5

Notes on the sheet:
EN - Adj Input Undervoltage Lockout (UVLO)
V_start = 16.29V
V_stop = 15.3V
R1 = (V_start - V_end)/I_hist = 330Kohm
R2 = (V_en)/(I_hist + 1uA) = 26836ohm
R1 = 330Kohm R2 = 27Kohm
V_out - Set point
V_out = 3v3
V_out = V_ref*(R5/R6 - 1)
R5 = 9K1 R6 = 1K8 V_OUT = 3V24
Catch diode
Slow Start 1.32mS
Bulk Capacitors Delta V_in = 1.1V
Output Filter
L_min = (V_out * (Vin_max - Vout))/(Vin_max * K_ind * I_out * f_sw)
L_min = 6.8uH
Co_min = 1/(2*pi*F_CO(max))
Co_min = 6.875uF -> 10uF
ESR_max = 47.87mOhm

Schematic: bat_switch.sch, Battery Managment System (MBS)

Parts:
D20: D; D_SMA
Q11, Q12: BC848; SOT-23
Q13: IRF9310PbF; SO-8_3.9x4.9mm_P1.27mm
R63: 3.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R64: 33K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R65: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U5: FERD2045SB-TR; TO-252-2

Connections:
/LOAD_OUTPUT+: Q12.3 (C), Q13.1, Q13.2, Q13.3, R64.1; also elsewhere on the board
/bat_switch/D: Q13.5, Q13.6, Q13.7, Q13.8, U5.2; also elsewhere on the board
GND: Q11.2 (E), U5.1, U5.3; also elsewhere on the board
unnamed: D20.1 (K), Q12.1 (B), R64.2, R65.1
unnamed: D20.2 (A), Q12.2 (E), Q13.4
unnamed: Q11.1 (B), R63.1
unnamed: Q11.3 (C), R65.2

Parts:
C43, C46: 2.2uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C44, C45: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C47, C52: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C48, C49, C50, C51, C53, C54, C55, C56, C57: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C58: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Vertical
L3: fcd0805; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
R66: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R67: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R68: 47; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW3: SW_Push; SW_PUSH_6mm_H4.3mm
U6: STM32F407VGTx; LQFP-100_14x14mm_P0.5mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
/current_sensor_ina226/SCL: U6.92 (PB6); also elsewhere on the board
/current_sensor_ina226/SDA: U6.93 (PB7); also elsewhere on the board
/equalizer_bq76/ALERT_BQ76: U6.34 (PC5); also elsewhere on the board
/equalizer_bq76/CS: U6.29 (PA4); also elsewhere on the board
/mcu_stm32f407/BQ24_CE: U6.18 (PC3); also elsewhere on the board
/mcu_stm32f407/BQ24_PG: U6.15 (PC0); also elsewhere on the board
/mcu_stm32f407/BQ24_STAT1: U6.17 (PC2); also elsewhere on the board
/mcu_stm32f407/BQ24_STAT2: U6.16 (PC1); also elsewhere on the board
/mcu_stm32f407/BQ76_CONV: U6.36 (PB1); also elsewhere on the board
/mcu_stm32f407/BQ76_DRDY: U6.35 (PB0); also elsewhere on the board
/mcu_stm32f407/BQ76_FAULT: U6.33 (PC4); also elsewhere on the board
/mcu_stm32f407/CAN_1RX: U6.70 (PA11); also elsewhere on the board
/mcu_stm32f407/CAN_1TX: U6.71 (PA12); also elsewhere on the board
/mcu_stm32f407/MISO: U6.31 (PA6); also elsewhere on the board
/mcu_stm32f407/MOSI: U6.32 (PA7); also elsewhere on the board
/mcu_stm32f407/SCK: U6.30 (PA5); also elsewhere on the board
GND: C43.2, C44.1, C45.1, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, J1.4, J5.5, SW3.1, U6.10 (VSS), U6.20 (VSSA), U6.27 (VSS), U6.37 (PB2), U6.74 (VSS), U6.94 (BOOT0), U6.99 (VSS); also elsewhere on the board
NRST: J5.4, R67.2, SW3.2, U6.14 (NRST)
unnamed: C43.1, U6.49 (VCAP_1)
unnamed: C44.2, U6.12 (PH0), Y1.1
unnamed: C45.2, R66.2, Y1.2
unnamed: C46.1, U6.73 (VCAP_2)
unnamed: R66.1, U6.13 (PH1)
PB3: U6.89 (PB3)
SWCLK: J5.3, U6.76 (PA14)
SWDIO: J5.2, U6.72 (PA13)
UART_RX: J1.2, U6.83 (PD2)
UART_TX: J1.3, U6.80 (PC12)
VBAT: C48.1, C50.1, C51.1, C53.1, C55.1, C56.1, C57.1, C58.1, J1.1, J5.1, L3.1, R67.1, U6.6 (VBAT), U6.11 (VDD), U6.19 (VDD), U6.28 (VDD), U6.50 (VDD), U6.75 (VDD), U6.100 (VDD); also elsewhere on the board
VDDA: C47.1, C49.1, L3.2, R68.1, U6.22 (VDDA)
VREF+: C52.1, C54.1, R68.2, U6.21 (VREF+)

Notes on the sheet:
The V_BAT pin supplies the RTC, the backup registers and the backup SRAM. When the mcu is supplied from V_BAT, external interrupts and RTC alarm/events do not exit it from V_BAT operation
BOOT pins configuration BOOT 0 BOOT 1 MODE 0 X Main flash memory boot <- Selected 1 0 System Memory boot (boot loader) 1 1 RAM memory
SWD
The VDD pins must be connected to VDD with external decoupling capacitors: one single Tantalum or Ceramic capacitor (min. 4.7 μF typ. 10 μF) for the package + one 100 nF Ceramic capacitor for each VDD pin.
The VBAT pin can be connected to the external battery (1.65 V < VBAT < 3.6 V). If no external battery is used, it is recommended to connect this pin to VDD with a 100 nF external ceramic decoupling capacitor.
The VDDA pin must be connected to two external decoupling capacitors (100 nF Ceramic + 1 μF Tantalum or Ceramic).
Additional precautions can be taken to filter analog noise: –VDDA can be connected to VDD through a ferrite bead. –The VREF+ pin can be connected to VDDA through a 47ohm resistor
UART

Parts:
C59: 330nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C60: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C61: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C62, C63: 100pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J6: DB9_Male; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
R5: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7: 60; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ADuM1201AR; SOIC-8_3.9x4.9mm_P1.27mm
U7: PDM1-S12-S3-S; CONV_PDM1-S12-S3-S; PARTREV 1.02
U8: SN65HVD233; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/can_hw/CANH: C63.1, J6.7, R7.1, U8.7 (CANH)
/can_hw/CANL: C62.1, J6.2, R6.2, U8.6 (CANL)
/mcu_stm32f407/CAN_1RX: U1.2 (VOA); also elsewhere on the board
/mcu_stm32f407/CAN_1TX: U1.3 (VIB); also elsewhere on the board
GND: C59.2, U1.4 (GND1), U7.2; also elsewhere on the board
GND2: C60.2, C61.2, C62.2, C63.2, J6.3, J6.6, R5.2, U1.5 (GND2), U7.4, U8.2 (GND)
ISO_3V3: C60.1, U7.6, U8.3 (VCC)
ISO_CAN_RX: U1.7 (VIA), U8.4 (R)
ISO_CAN_TX: U1.6 (VOB), U8.1 (D)
unnamed: C61.1, R6.1, R7.2
unnamed: R5.1, U8.8 (Rs)
VBAT: C59.1, U1.1 (VDD1), U7.1; also elsewhere on the board
