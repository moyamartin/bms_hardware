# Repository moyamartin/bms_hardware (continued)

## KiCad design hw_balanceo/bat_balancing/bat_balancing.kicad_pcb

Parts:
C1, C6, C17: 2.2uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 10uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 10nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C5, C16: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C15: 0.1uF 50v; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
GPAI1: Conn_GPAI; PinHeader_1x02_P2.54mm_Vertical
GPIO1: Conn_GPIO; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x07; JST_XH_S07B-XH-A_1x07_P2.50mm_Horizontal
J5, J6: NTC; JST_XH_S02B-XH-A_1x02_P2.50mm_Horizontal
J7: Conn_REG50; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9, R11: 1K47; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10, R12: 1K82; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R37, R38, R39: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: bq76pl536; HTQFP-64-1EP_10x10mm_P0.5mm_EP8x8mm

Connections:
/Balancing Module/CB1: U1.12 (CB1); also elsewhere on the board
/Balancing Module/CB2: U1.10 (CB2); also elsewhere on the board
/Balancing Module/CB3: U1.8 (CB3); also elsewhere on the board
/Balancing Module/CB4: U1.6 (CB4); also elsewhere on the board
/Balancing Module/CB5: U1.4 (CB5); also elsewhere on the board
/Balancing Module/CB6: U1.2 (CB6); also elsewhere on the board
/Balancing Module/Cell1+: J4.6; also elsewhere on the board
/Balancing Module/Cell2+: J4.5; also elsewhere on the board
/Balancing Module/Cell3+: J4.4; also elsewhere on the board
/Balancing Module/Cell4+: J4.3; also elsewhere on the board
/Balancing Module/Cell5+: J4.2; also elsewhere on the board
/Balancing Module/VC1: U1.11 (VC1); also elsewhere on the board
/Balancing Module/VC2: U1.9 (VC2); also elsewhere on the board
/Balancing Module/VC3: U1.7 (VC3); also elsewhere on the board
/Balancing Module/VC4: U1.5 (VC4); also elsewhere on the board
/Balancing Module/VC5: U1.3 (VC5); also elsewhere on the board
/Balancing Module/VC6: U1.1 (VC6); also elsewhere on the board
/TSN1: R10.2, U1.19 (TS1-)
/TSN2: R12.2, U1.60 (TS2-)
/TSP1: C3.1, R9.2, R10.1, U1.20 (TS1+)
/TSP2: C4.1, R11.2, R12.1, U1.61 (TS2+)
/V_batt: C15.2, J4.1, U1.52 (CS_N), U1.53 (SDI_N), U1.54 (SDO_N), U1.55 (SCLK_N), U1.56 (FAULT_N), U1.57 (ALERT_N), U1.58 (DRDY_N), U1.59 (CONV_N), U1.63 (BAT1), U1.64 (BAT2); also elsewhere on the board
GPAI1: GPAI1.1, U1.48 (GPAI+)
GPAI2: GPAI1.2, R38.1, U1.47 (GPAI-)
GPIO: GPIO1.1, R39.1, U1.45 (GPIO)
HSEL: R37.2, U1.44 (HSEL)
LDOA: C5.1, C6.1, U1.17 (LDOA)
LDOD: C16.1, C17.1, U1.18 (LDOD1), U1.46 (LDOD2); also elsewhere on the board
unnamed: C2.2, U1.16 (VREF)
unnamed 35: R1.2; also elsewhere on the board
unnamed 36: R2.2; also elsewhere on the board
unnamed 37: R3.2; also elsewhere on the board
unnamed 38: R4.2; also elsewhere on the board
unnamed 39: R5.2; also elsewhere on the board
unnamed 40: R6.2; also elsewhere on the board
unnamed 41: R7.2; also elsewhere on the board
unnamed 42: R8.2; also elsewhere on the board
unnamed: J5.2, R9.1
unnamed: J6.1, R11.1
unnamed: R1.1, U1.43 (CS_H)
unnamed: R2.1, U1.42 (SDI_H)
unnamed: R3.1, U1.41 (SDO_H)
unnamed: R4.1, U1.40 (SCLK_H)
unnamed: R5.1, U1.39 (FAULT_H)
unnamed: R6.1, U1.38 (ALERT_H)
unnamed: R7.1, U1.37 (DRDY_H)
unnamed: R8.1, U1.36 (CONV_H)
REG50: C1.1, C3.2, C4.2, J5.1, J6.2, J7.1, R39.2, U1.32 (REG50)

Notes on the sheet:
HSEL 1 - 2 On 2 - 3 Off

Parts:
C7, C8, C9, C10, C13, C14: 0.1uF 50V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C_IN1, C_IN2, C_IN3, C_IN4, C_IN5, C_IN6: 0.1uF 50V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6: 5V6; D_SOD-123
D_TVS1, D_TVS2, D_TVS5, D_TVS6: 5V6 500mW; D_SOD-123
D_TVS3, D_TVS4: 5V6; D_SOD-123
Q1, Q2, Q3, Q4, Q5, Q6: 2N7002; SOT-23
R13, R14, R15, R16, R23, R24: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R17, R18, R19, R20, R25, R26: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R_BAL1, R_BAL2, R_BAL3, R_BAL4, R_BAL5, R_BAL6: 47; R_1210_3225Metric
R_IN1, R_IN2, R_IN3, R_IN4, R_IN5, R_IN6: 1K, 1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
/Balancing Module/CB1: R24.1; also elsewhere on the board
/Balancing Module/CB2: R23.1; also elsewhere on the board
/Balancing Module/CB3: R16.1; also elsewhere on the board
/Balancing Module/CB4: R15.1; also elsewhere on the board
/Balancing Module/CB5: R14.1; also elsewhere on the board
/Balancing Module/CB6: R13.1; also elsewhere on the board
/Balancing Module/Cell1+: C13.2, C14.1, C_IN1.1, D5.2 (A), D_TVS1.1 (K), D_TVS2.2 (A), Q2.2 (S), R25.2, R_BAL1.1, R_IN1.1; also elsewhere on the board
/Balancing Module/Cell2+: C10.2, C13.1, C_IN2.1, D4.2 (A), D_TVS2.1 (K), D_TVS3.2 (A), Q3.2 (S), R20.2, R_BAL2.1, R_IN2.1; also elsewhere on the board
/Balancing Module/Cell3+: C9.2, C10.1, C_IN3.1, D3.2 (A), D_TVS3.1 (K), D_TVS4.2 (A), Q4.2 (S), R19.2, R_BAL3.1, R_IN3.1; also elsewhere on the board
/Balancing Module/Cell4+: C8.2, C9.1, C_IN4.1, D2.2 (A), D_TVS4.1 (K), D_TVS5.2 (A), Q5.2 (S), R18.2, R_BAL4.1, R_IN4.1; also elsewhere on the board
/Balancing Module/Cell5+: C7.2, C8.1, C_IN5.1, D1.2 (A), D_TVS5.1 (K), D_TVS6.2 (A), Q6.2 (S), R17.2, R_BAL5.1, R_IN5.1; also elsewhere on the board
/Balancing Module/VC1: R_IN1.2; also elsewhere on the board
/Balancing Module/VC2: R_IN2.2; also elsewhere on the board
/Balancing Module/VC3: R_IN3.2; also elsewhere on the board
/Balancing Module/VC4: R_IN4.2; also elsewhere on the board
/Balancing Module/VC5: R_IN5.2; also elsewhere on the board
/Balancing Module/VC6: R_IN6.2; also elsewhere on the board
/V_batt: C7.1, C_IN6.1, D_TVS6.1 (K), R_BAL6.1, R_IN6.1; also elsewhere on the board
unnamed: D1.1 (K), Q6.1 (G), R13.2, R17.1
unnamed: D2.1 (K), Q5.1 (G), R14.2, R18.1
unnamed: D3.1 (K), Q4.1 (G), R15.2, R19.1
unnamed: D4.1 (K), Q3.1 (G), R16.2, R20.1
unnamed: D5.1 (K), Q2.1 (G), R23.2, R25.1
unnamed: D6.1 (K), Q1.1 (G), R24.2, R26.1
unnamed: Q1.3 (D), R_BAL1.2
unnamed: Q2.3 (D), R_BAL2.2
unnamed: Q3.3 (D), R_BAL3.2
unnamed: Q4.3 (D), R_BAL4.2
unnamed: Q5.3 (D), R_BAL5.2
unnamed: Q6.3 (D), R_BAL6.2

Notes on the sheet:
* 2N7002 Puede ser reemplazado por el BSS138

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
Board: 2 copper layers, 43.0 x 73.0 mm, 87 parts (33 on the bottom side), 62 nets.

Other parts of the board:
HSEL1: Jumper_HSEL; PinHeader_1x03_P2.54mm_Vertical
J1: Conn_01x08; PinHeader_1x08_P2.54mm_Horizontal

Their connections:
LDOD: HSEL1.1; also elsewhere on the board
unnamed 35: J1.1; also elsewhere on the board
unnamed 36: J1.2; also elsewhere on the board
unnamed 37: J1.3; also elsewhere on the board
unnamed 38: J1.4; also elsewhere on the board
unnamed 39: J1.5; also elsewhere on the board
unnamed 40: J1.6; also elsewhere on the board
unnamed 41: J1.7; also elsewhere on the board
unnamed 42: J1.8; also elsewhere on the board

## KiCad design Dropbox/Hardware/dc_load_400W/dc_load_adaptado_CNC/dc_load_hmi/dc_load_hmi.kicad_pcb

Board: 2 copper layers, 98.0 x 102.4 mm, 10 parts (0 on the bottom side), 13 nets.

Parts:
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.5mm_Pad
J1: Conn_01x16; LCD-20x04
J2: Conn_01x12_Male; JST_XH_S12B-XH-A_1x12_P2.50mm_Horizontal
RV1: R_POT_TRIM; Potentiometer_Bourns_3296W_Vertical
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm

Connections:
+3V3: J2.3, SW1.C
+5V: J1.2, J1.15, J2.2, RV1.1
/D4: J1.11, J2.6
/D5: J1.12, J2.7
/D6: J1.13, J2.8
/D7: J1.14, J2.9
/E: J1.6, J2.5
/RS: J1.4, J2.4
/SEL_SP: J2.12, SW1.S1
ENC_A: J2.10, SW1.A
ENC_B: J2.11, SW1.B
GND: J1.1, J1.5, J1.16, J2.1, RV1.3, SW1.S2
unnamed: J1.3, RV1.2

## Commit log

2020-03-14 Agrega .gitignore para Eagle
2020-03-14 Agrega .gitignore KiCAD por si acaso
2020-03-14 Init proyecto Kicad
2020-03-14 Agrega STM32 MCU
2020-11-28 Agrego archivos bajados del Dropbox/Hardware/Anexos
    Creo proyecto KiCAD para crear el cargador de baterias
2020-12-24 First charger sch version.
    TODO:
    + Imput Snubber
    + Select Q & N power MOS
    + Calc L & C
    + Tempr Sens
2020-12-26 Adds MCU STM32F407
2020-12-27 mmoya/bq76pl536a Adds bq76p536a
    TODO: Calculate resistance divider for temp sensors
2020-12-27 mmoya/bq76pl536a Adds current sensor and IO for hierarchical sheet
2020-12-27 mmoya/bq76pl536a deletes unnecesary folders
2020-12-27 Adds missing footprints for conns
2020-12-27 Adds missing connectors footprints
2020-12-27 reeplaces 0815 footprint to 0805
2020-12-28 mmoya/ina226 Adds ina226 current sensor
    - Expects a max current of 20A
    - Adds pcb footprint
2021-01-01 Adds SPI port to STM32F407VGxx
2021-01-03 Changes overlapping names of pins between bq76 and ina226
2021-01-14 Agrego Datasheets utiles al proyecto
2021-01-14 Agrego lib de componentes faltantes al proyecto
2021-01-14 Avances del esquematico:
    + Imput Snubber DONE!
    + Select Q & N power MOS DONE!
    + Calc L & C DONE!
    TODO:
    + Tempr Sens
2021-01-14 Added bat_charger.sch to main hierarchical bms project
2021-01-14 Clean old bar_charger.pro
2021-01-15 Charger Temperature Sensor bypassed!
2021-01-20 ADds 3v3 buck converter
2021-01-20 Reserved mcu CAN pins & edited MOS names on Bat_charger
2021-02-06 Changes only global labels to main page
2021-02-06 Adds aux pins for bq76
2021-02-06 Adds Can Pins
2021-02-06 Add explanations of Vdd filters
2021-02-07 Dletes hw_balanceo folder
2021-02-09 se agrega switch de barteria_carga
2021-02-09 Adds bat_switch to main sheet
2021-02-19 Fixes missing footprints, adds initial pcb
2021-02-24 Added mouser reference.com to charger imput molex pin
2021-02-24 Adds pcb file
2021-02-24 add minor changes to schs
2021-02-25 Module Can .sch and lib/PEP1-S5-D5-M added
2021-02-27 Adds final pcb
2021-02-27 Changes camel case convention to lower case
2021-03-03 Final version pcb
2021-03-03 Mirrors in x axis J3
2021-03-03 Reorder battery connection pins
2021-03-03 Minor fix
2021-03-04 Minor changes to 3v3 buck converter
2021-03-04 Adds ibom to project
2021-03-04 moves bom to docs folder
2021-03-04 deletes bom folder
2021-03-04 Adds rev A
2021-03-04 Updates README.md, add render files
2021-03-04 Updates render files
2021-03-04 Updates ibom index.html
2021-03-04 Links BOM and render files
2021-03-04 Fixes minimum track
2021-03-04 Adds labels to indication leds
2021-03-04 Minor typo in README
2021-03-04 Changes gnd planes clearance to 0.127mm (JLCPCB capability)
2021-03-04 Adds ground plane between i2c signals
2021-03-04 deletes unnecesary vias
2021-03-04 Adds gerber files
2021-03-04 Fixes silkscreen errors
2021-03-12 Edited sch page settings & printed schematic pdf
2021-03-22 Add initial notes for REV_B board
2021-10-01 who knows
