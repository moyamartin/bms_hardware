# Repository moyamartin/bms_hardware (continued)

## KiCad design bms_hardware.kicad_pcb (continued)

Parts:
C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: BZT52; D_SOD-123
Q1, Q2, Q3, Q4, Q5, Q6: 2N7002; SOT-23
R12, R13, R14, R24, R25, R26: 1K, 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16, R17, R27, R28, R29: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R19, R20, R30, R31, R32: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R22, R23, R33, R34, R35: 47@1/2W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
+24V: C10.1, C13.1, D4.1 (K), R12.1, R21.1; also elsewhere on the board
/equalizer_bq76/balancing_module/CB1: R29.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CB2: R28.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CB3: R27.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CB4: R17.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CB5: R16.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CB6: R15.2; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_1+: C18.1, C20.2, C21.1, D8.2 (A), D11.2 (A), D12.1 (K), Q5.2 (S), R26.1, R31.2, R35.1; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_2+: C17.1, C19.2, C20.1, D7.2 (A), D10.2 (A), D11.1 (K), Q4.2 (S), R25.1, R30.2, R34.1; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_3+: C15.2, C16.1, C19.1, D3.2 (A), D6.2 (A), D10.1 (K), Q3.2 (S), R20.2, R24.1, R33.1; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_4+: C12.1, C14.2, C15.1, D2.2 (A), D5.2 (A), D6.1 (K), Q2.2 (S), R14.1, R19.2, R23.1; also elsewhere on the board
/equalizer_bq76/balancing_module/CELL_5+: C11.1, C13.2, C14.1, D1.2 (A), D4.2 (A), D5.1 (K), Q1.2 (S), R13.1, R18.2, R22.1; also elsewhere on the board
/equalizer_bq76/balancing_module/VC1: R26.2; also elsewhere on the board
/equalizer_bq76/balancing_module/VC2: R25.2; also elsewhere on the board
/equalizer_bq76/balancing_module/VC3: R24.2; also elsewhere on the board
/equalizer_bq76/balancing_module/VC4: R14.2; also elsewhere on the board
/equalizer_bq76/balancing_module/VC5: R13.2; also elsewhere on the board
/equalizer_bq76/balancing_module/VC6: R12.2; also elsewhere on the board
GND: C10.2, C11.2, C12.2, C16.2, C17.2, C18.2, C21.2, D9.2 (A), D12.2 (A), Q6.2 (S), R32.2; also elsewhere on the board
unnamed: D1.1 (K), Q1.1 (G), R15.1, R18.1
unnamed: D2.1 (K), Q2.1 (G), R16.1, R19.1
unnamed: D3.1 (K), Q3.1 (G), R17.1, R20.1
unnamed: D7.1 (K), Q4.1 (G), R27.1, R30.1
unnamed: D8.1 (K), Q5.1 (G), R28.1, R31.1
unnamed: D9.1 (K), Q6.1 (G), R29.1, R32.1
unnamed: Q1.3 (D), R21.2
unnamed: Q2.3 (D), R22.2
unnamed: Q3.3 (D), R23.2
unnamed: Q4.3 (D), R33.2
unnamed: Q5.3 (D), R34.2
unnamed: Q6.3 (D), R35.2

Notes on the sheet:
Avoid hot-plug transient voltages
anti-aliasing filter

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
Board: 2 copper layers, 150.6 x 71.7 mm, 197 parts (35 on the bottom side), 125 nets.

Other parts of the board:
+(BATT): MountingHole_Pad; MountingHole_3mm_Pad_TopBottom
-(BATT): MountingHole_Pad; MountingHole_3mm_Pad_TopBottom

Their connections:
+BATT: +(BATT).1; also elsewhere on the board
GND: -(BATT).1; also elsewhere on the board

## KiCad design Dropbox/Hardware/modulo_opto/modulo_opto.kicad_pcb

Schematic: modulo_opto.sch

Parts:
C1, C2, C3, C4: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3, R4: 200; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2, U3, U4: 6N137; DIP-8_W7.62mm_LongPads

Connections:
/5V: C4.1, J2.5, U3.8 (VCC)
/CS: J2.1, R2.2
/CS_H: J1.1, U1.6 (VO)
/GND_BMS: C2.2, C3.2, J1.6, U1.5 (GND), U2.5 (GND), U3.3 (VF-)
/GND_MCU: C4.2, J2.6, U1.3 (VF-), U2.3 (VF-), U3.5 (GND), U4.3 (VF-)
/LDOD: C1.1, C2.1, C3.1, J1.5, U1.8 (VCC), U2.8 (VCC), U4.8 (VCC)
/MISO: J2.3, R8.1
/MOSI: J2.2, R3.2
/SCK: J2.4, R1.1
/SCK_H: J1.4, U4.6 (VO)
/SDI_H: J1.2, U2.6 (VO)
/SDO_H: J1.3, R4.2
GND: C1.2, U4.5 (GND)
unnamed: R1.2, U4.2 (VF+)
unnamed: R2.1, U1.2 (VF+)
unnamed: R3.1, U2.2 (VF+)
unnamed: R4.1, U3.2 (VF+)
unnamed: R8.2, U3.6 (VO)

Board: 2 copper layers, 15 parts (11 on the bottom side), 18 nets, no tracks yet.

## KiCad design Dropbox/Hardware/dc_load_25W/dc_load_25W.kicad_pcb

Parts:
C1: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C7: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 0.1uF; CP_Radial_D6.3mm_P2.50mm
C4: 100uF; CP_Radial_D5.0mm_P2.50mm
C5: 1uF; CP_Radial_D5.0mm_P2.50mm
C6: 10uF/10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: D_Schottky; D_DO-34_SOD68_P7.62mm_Horizontal
F1: Fuse; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
H1: LCD_1_MH; MountingHole_2.5mm_Pad_Via
H2: LCD_2_MH; MountingHole_2.5mm_Pad_Via
H3: LCD_3_MH; MountingHole_2.5mm_Pad_Via
H4: LCD_4_MH; MountingHole_2.5mm_Pad_Via
J1: Jack-DC; BarrelJack_Horizontal
J2: Programador; PinHeader_1x06_P2.54mm_Vertical
J3: LCD1604; WINSTAR-WH1604A
J4: Batería; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J5: Cooler; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q1: IRFP064N; TO-247-3_Vertical
Q2: BC548; TO-92_Inline
Q3: IRF540N; TO-220-3_Horizontal_TabDown
R1: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R6: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R9, R10: 100K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 39K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8: 0.05 2W 1%; R_2512_6332Metric_Pad1.52x3.35mm_HandSolder
R11, R12, R15: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13, R14: 180K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16: 27K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R17: 12K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R28: 820; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R29: 270; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: R_POT_TRIM; Potentiometer_Bourns_3296W_Vertical
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm
TP1: 3V3_TP; TestPoint_Pad_D1.5mm
TP2: 5V_TP; TestPoint_Pad_D1.5mm
TP3: PWM_TP; TestPoint_Pad_D1.5mm
TP4: PWM_F_TP; TestPoint_Pad_D1.5mm
TP5: ADC_I_TP; TestPoint_Pad_D1.5mm
TP6: TestPoint; TestPoint_Pad_D1.5mm
TP7: I_batt; TestPoint_Pad_D1.5mm
TP8: V_BATT_TP; TestPoint_Pad_D1.5mm
TP9: 2V5_TP; TestPoint_Pad_D1.5mm
TP10: TEMP_TP; TestPoint_Pad_D1.5mm
U1: LM317_3PinPackage; TO-220-3_Horizontal_TabDown
U2: LM385Z-2.5; TO-92_Inline
U3: MSP430G2553IPW28; TSSOP-28_4.4x9.7mm_P0.65mm
U4: TL084
U5: LM35-NEB; TO-220-3_Vertical
U6: TL081; DIP-8_W7.62mm_LongPads
U10: AMS1117-3.3; SOT-223-3_TabPin2
Y1: 32768Hz; Crystal_SMD_MicroCrystal_MS3V-T1R

Connections:
+2V5: R7.1, R9.2, TP9.1, U2.3 (A)
+3V3: C4.1, C6.2, C7.2, J2.2, R1.1, R7.2, TP1.1, U3.1 (DVCC), U10.2 (VO)
+5V: C1.2, C5.1, J3.2, R29.2, RV1.1, TP2.1, U1.2 (VO), U4.4 (V+), U5.1 (+VS), U6.7 (V+), U10.3 (VI)
+12V: C3.2, D1.1 (K), J1.1, J5.1, R17.2, U1.3 (VI)
/I_batt: Q1.3 (S), R8.1, TP7.1, U4.6 (-), U4.10 (+)
/RST: C2.2, J2.4, R1.2, U3.24 (~RST~/NMI/SBWTDIO)
/RX: J2.6, U3.3 (TA0.0/UCA0RXD/UCA0SOMI/A1/CA1/P1.1)
/TEST: J2.3, U3.25 (SBWTCK/TEST)
/TX: J2.5, U3.4 (TA0.1/UCA0TXD/UCA0SIMO/A2/CA2/P1.2)
ADC_I: R5.2, TP5.1, U3.23 (TDO/TDI/CAOUT/UCB0SIMO/UCB0SDA/A7/CA7/P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), U4.8
BAT+: F1.2, J4.1, R10.2
CTRST: J3.3, RV1.2
D4: J3.11, U3.10 (TA1.0/P2.0)
D5: J3.12, U3.11 (TA1.1/P2.1)
D6: J3.13, U3.12 (TA1.1/P2.2)
D7: J3.14, U3.13 (P3.2/TA1.1)
E: J3.6, U3.9 (P3.0/TA0.2)
ENC_A: SW1.A, U3.16 (TA1.0/P2.3)
ENC_B: SW1.B, U3.18 (TA1.2/P2.5)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.2, J1.2, J2.1, J3.1, J3.5, J4.2, Q2.3, Q3.3, R3.1, R6.2, R8.2, R12.2, R13.1, R28.1, RV1.3, SW1.C, SW1.S2, U2.2 (K), U3.28 (DVSS), U4.11 (V-), U5.2 (GND), U6.4 (V-), U10.1 (GND), Y1.3
unnamed: C8.1, R2.1, TP4.1, U4.3 (+)
unnamed: F1.1, Q1.1 (D)
unnamed: Q1.2 (G), U4.7
unnamed: Q2.1, Q3.1, R17.1
unnamed: Q2.2, R16.2
unnamed: R3.2, R5.1, U4.9 (-)
unnamed: R4.1, R6.1, TP6.1, U4.5 (+)
unnamed: R4.2, U4.1, U4.2 (-)
unnamed: R10.1, R13.2, U4.12 (+)
unnamed: R11.1, TP10.1, U6.3 (+)
unnamed: R11.2, U5.3 (Vout)
unnamed: R12.1, R15.2, U6.2 (-)
unnamed: R9.1, R14.1, U4.13 (-)
unnamed: R28.2, R29.1, U1.1 (ADJ)
unnamed: U3.26 (XOUT/P2.7), Y1.1
unnamed: U3.27 (TA0.1/XIN/P2.6), Y1.2
PWM: R2.2, TP3.1, U3.20 (P3.6/TA0.2)
PWM_12: D1.2 (A), J5.2, Q3.2
PWM_F: R16.1, U3.14 (P3.3/TA1.2)
RS: J3.4, U3.8 (P3.1/TA1.0)
SEL_SP: SW1.S1, U3.6 (TCK/SMCLK/UCB0STE/UCA0CLK/VREF+/VeREF+/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)
V_BATT_SENSE: R14.2, TP8.1, U3.22 (TDI/TCLK/TA0.1/UCB0SOMI/UCB0SCL/A6/CA6/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), U4.14
V_TEMP: R15.1, U3.2 (TA0CLK/ACLK/A0/CA0/P1.0), U6.6

Notes on the sheet:
Alimentación 5V 3V3 2V5 (Diodo zener)
HMI
Etapa potencia
Medición Voltaje Batería
Microcontrolador
Note: 32768Hz Crystal is needed in case of low power and precise clock (e.g. It can be used to generate a Real Time Clock)
Sensor de Temperatura (10mV/°C)
150°C ------- 3 (Ganancia AO 2)
Medición Corriente Ganancia AO = 11
Ganancia: (180K/100K)*(BAT+ - 2.5V)
TODO: * Averiguar como se llama el conector del cooler * Recalcular tensión de base del MOSFET (para dimensionar la alimentación del AO al gate del MOSFET) * Hacer tapa de potencia cooler (Lucio) (OK) DONE: * Recalcular divisor resistivo a la entrada de U5B para los valores deseados de corriente (O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
Drill Holes
Diodo Flyback

Board: 2 copper layers, 122.3 x 125.1 mm, 61 parts (3 on the bottom side), 43 nets.

File Dropbox/Hardware/dc_load_25W/Lista componentes/Listado Componentes .xlsx:

Componente | Tipo | Valor | Observacion | cantidad | disponible | Mercadolibre | local
C1, C2 | 0.1uF |  | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | #N/A | SI | En envio
C3 | 0.1uF |  | Capacitor_THT:CP_Radial_D6.3mm_P2.50mm | 1 | NO
C4 | 100uF |  | Capacitor_THT:CP_Radial_D5.0mm_P2.50mm | 1 | NO
C5 | 1uF |  | Capacitor_THT:CP_Radial_D5.0mm_P2.50mm | 1 | NO
C6 | 10uF/10V |  | Capacitor_THT:CP_Radial_D5.0mm_P2.50mm | 1 | NO
C8 | 1uF |  | Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | En envio
D1 | D_Schottky |  | Diode_THT:D_DO-34_SOD68_P7.62mm_Horizontal | 1 | SI
F1 | Fuse | Fuse | Fuse:Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Open | 1 | NO
J1 | Jack-DC | Jack-DC-Connector | Connector_BarrelJack:BarrelJack_Horizontal | 1 | NO
J2 | Programador | Conn_01x06_Male-Connector | Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical | 1 | SI | En envio
J3 | LCD2004 | Conn_01x14_Female-Connector | Display:WINSTAR-WH1604A | 1 | SI
J4 | Batería | Conn_01x02_Male-Connector | TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1 | 1 | NO
J5 | Cooler | Conn_01x04-Connector_Generic | Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical | 1 | NO
Q1 | IRFP064N | IRFP064N-Transistor_FET | Package_TO_SOT_THT:TO-247-3_Vertical | 1 | SI
Q2 | BC548 | BC548 | Package_TO_SOT_THT:TO-92_Inline | 1 | SI
Q3 | IRF540N | IRF540N | Package_TO_SOT_THT:TO-220-3_Horizontal_TabDown | 1 | SI
R1 | 47k |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | En envio
R2 | 10k |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 3 | SI | En envio
R4, R5 | 100k |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | #N/A | SI | en envio
 | 39K |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | #N/A | SI | En envio
R8 | 0.05 2W 1% |  | Resistor_SMD:R_2512_6332Metric_Pad1.52x3.35mm_HandSolder | 1 | SI
R13 | 180K |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | En envio
R16 | 27K |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | En envio
R17 | 12K |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | En envio
R28 | 820 |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | en envio
R29 | 270 |  | Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | SI | En envio
RV1 | R_POT_TRIM | R_POT_TRIM-Device | Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical | 1 | NO
SW1 | Rotary_Encoder_Switch | Rotary_Encoder_Switch-Device | Rotary_Encoder:RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm | 1 | SI | En envio
U1 | LM317_3PinPackage | LM317_3PinPackage-Regulator_Linear | Package_TO_SOT_THT:TO-220-3_Horizontal_TabDown | 1 | NO
U2 | LM385Z-2.5 | LM385Z-2.5-Reference_Voltage | Package_TO_SOT_THT:TO-92_Inline | 1 | SI | En Envio
U3 | MSP430G2553IPW28 | MSP430G2553IPW28-MCU_Texas_MSP430 | Package_SO:TSSOP-28_4.4x9.7mm_P0.65mm | 1 | SI
U4 | TL084 | TL084-Amplifier_Operational | Package_SO:SOIC-14_3.9x8.7mm_P1.27mm | 1 | SI
U5 | LM35-NEB | LM35-NEB-Sensor_Temperature | Package_TO_SOT_THT:TO-220-3_Vertical | 1 | SI | En envio
U6 | TL081 | TL081-Amplifier_Operational | Package_DIP:DIP-8_W7.62mm_LongPads | 1 | NO
U10 | AMS1117-3.3 | AMS1117-3.3-Regulator_Linear | Package_TO_SOT_SMD:SOT-223-3_TabPin2 | 1 | SI | En envio
Y1 | 32768Hz | Crystal_GND3_Small-Device | Crystal:Crystal_SMD_MicroCrystal_MS3V-T1R | 1 | NO

## KiCad design Dropbox/Hardware/dc_load_400W/dc_load_adaptado_CNC/dc_load.kicad_pcb

Board: 2 copper layers, 62 parts (0 on the bottom side), 51 nets.

Parts:
C1, C5: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C7: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 0.1uF; CP_Radial_D6.3mm_P2.50mm
C6: 10uF/10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8, C9, C12, C13: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C11: 12pF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Jack-DC; BarrelJack_Horizontal
J2: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J5: Conn_01x14_Male; JST_XH_S14B-XH-A_1x14_P2.50mm_Horizontal
J6, J7: Conn_01x02_Female; JST_XH_B02B-XH-A_1x02_P2.50mm_Vertical
Q1, Q2, Q3, Q4: IRFP064N; TO-247-3_Vertical
R1: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R6, R7, R10, R11, R14, R15, R20, R21, R24, R25: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R5, R12, R13: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8, R9, R16, R17: 0.05 2W 1%; R_1020_2550Metric_Pad1.33x5.20mm_HandSolder
R18, R19, R22, R23: 82k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R26: 100K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R27: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R28: 720; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R29: 240; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: LM317_3PinPackage; TO-220-3_Horizontal_TabDown
U2, U6, U7, U8, U9: AD8603; TSOT-23-5
U3: MSP430G2553IPW28; TSSOP-28_4.4x9.7mm_P0.65mm
U4: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm
U5: TL084; SOIC-14_3.9x8.7mm_P1.27mm
U10: AMS1117-3.3; SOT-223-3_TabPin2
Y1: Crystal_GND3_Small; Crystal_SMD_MicroCrystal_MS3V-T1R

Connections:
3V3: C5.2, C6.2, C7.2, J2.2, J5.3, R1.1, U2.5, U3.1, U4.4, U6.5, U7.5, U8.5, U9.5, U10.2
+5V: C1.2, C4.2, J5.2, R29.2, U1.2, U5.4, U10.3
+12V: C3.2, J1.1, J6.2, J7.2, U1.3
/BATT_BOARD: Q1.1, Q2.1, Q3.1, Q4.1
/D4: J5.6, U3.9
/D5: J5.7, U3.8
/D6: J5.8, U3.13
/D7: J5.9, U3.14
/DER_STOP: J5.14, U3.12
/E: J5.5, U3.15
/ENC_A: J5.10, U3.16
/ENC_B: J5.11, U3.18
/IZQ_RUN: J5.13, U3.10
/I_1: Q1.3, R8.1, U5.6, U6.3
/I_2: Q4.3, R17.1, U5.9, U7.3
/I_3: Q2.3, R9.1, U5.2, U9.3
/I_4: Q3.3, R16.1, U5.13, U8.3
/P1.1: J2.6, R19.2, U3.3, U7.1
/P1.2: J2.5, R23.2, U3.4, U9.1
/PWM_1: R2.2, U3.20
/PWM_2: R3.2, U3.19
/PWM_3: R10.2, U3.11
/PWM_4: R11.2, U3.17
/RS: J5.4, U3.21
/RST: C2.2, J2.4, R1.2, U3.24
/SEL_SP: J5.12, U3.23
/TEST: J2.3, U3.25
/i_sense_adapter/AD_1: R18.2, U3.2, U6.1
/i_sense_adapter/AD_4: R22.2, U3.5, U8.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, J1.2, J2.1, J5.1, J6.1, J7.1, R6.2, R7.2, R8.2, R9.2, R14.2, R15.2, R16.2, R17.2, R20.1, R21.1, R24.1, R25.1, R27.2, R28.1, U2.2, U3.28, U4.11, U5.11, U6.2, U7.2, U8.2, U9.2, U10.1, Y1.3
unnamed: C8.1, R2.1, U4.3
unnamed: C9.1, R3.1, U4.5
unnamed: C10.2, U3.27, Y1.2
unnamed: C11.2, U3.26, Y1.1
unnamed: C12.1, R10.1, U4.12
unnamed: C13.1, R11.1, U4.10
unnamed: R4.1, R6.1, U5.5
unnamed: R4.2, U4.1, U4.2
unnamed: R5.1, R7.1, U5.3
unnamed: R5.2, U4.6, U4.7
unnamed: R12.1, R14.1, U5.12
unnamed: R12.2, U4.13, U4.14
unnamed: R13.1, R15.1, U5.10
unnamed: R13.2, U4.8, U4.9
unnamed: R18.1, R20.2, U6.4
unnamed: R19.1, R21.2, U7.4
unnamed: R22.1, R24.2, U8.4
unnamed: R23.1, R25.2, U9.4
unnamed: R26.2, R27.1, U2.3
unnamed: R28.2, R29.1, U1.1
V_BATT_SENSE: U2.1, U2.4, U3.6
